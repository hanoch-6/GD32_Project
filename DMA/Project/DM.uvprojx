# Keil uVision project DM.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F103RE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DM
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Library\CMSIS\GD\GD32F10x\Include;..\Library\CMSIS;..\Library\GD32F10x_standard_peripheral\Include;..\Others;..\Application;..\Freertos\include;..\Freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../Application/: gd32f10x_it.c main.c systick.c
  group CMSIS
    ../Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Utilities
    ../Others/: gd32f10x_eval.c
  group Freertos
    ../Freertos/Src/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Freertos/portable/MemMang/: heap_1.c
    ../Freertos/portable/RVDS/ARM_CM3/: port.c
